# Keil uVision project Quadpod.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quadpod
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Header File
    ./: stm32f407xx_1.h RCC.h LCD.h GPIO.h TIMER.h USART.h SPI.h common.h stm32f407xx.h
  group Source File
    ./: GPIO.cpp LCD.cpp RCC.cpp SPI.cpp TIMER.cpp USART.cpp common.cpp
  group main
    ./: main.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
